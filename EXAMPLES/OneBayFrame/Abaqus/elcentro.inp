** EL CENTRO 1940 NORTH-SOUTH COMPONENT (PEKNOLD VERSION)
** ACCELERATION TIME HISTORY IN UNITS OF G
** NPTS=  1559, DT= .02000 SEC
          0.,      2.43243,         0.02,     1.405404,         0.04,     0.382239,         0.06,     1.652508
        0.08,     2.926638,          0.1,     4.196907,         0.12,     2.633202,         0.14,     1.069497
        0.16,    -0.494208,         0.18,     1.420848,          0.2,     3.335904,         0.22,      5.25096
        0.24,     2.806947,         0.26,     0.362934,         0.28,      1.62162,          0.3,     0.853281
        0.32,     0.081081,         0.34,     1.714284,         0.36,     3.347487,         0.38,      4.98069
         0.4,     6.613893,         0.42,    -1.324323,         0.44,      -9.2664,         0.46,    -3.830112
        0.48,     1.606176,          0.5,     2.038608,         0.52,     6.382233,         0.54,    10.729719
        0.56,    15.073344,         0.58,     9.455589,          0.6,     3.841695,         0.62,     3.710421
        0.64,     3.575286,         0.66,     3.444012,         0.68,    -1.876446,          0.7,    -7.196904
        0.72,   -12.517362,         0.74,   -12.992265,         0.76,   -22.096503,         0.78,   -17.505774
         0.8,   -12.918906,         0.82,   -12.359061,         0.84,   -11.799216,         0.86,   -11.239371
        0.88,   -10.679526,          0.9,   -15.891876,         0.92,   -21.104226,         0.94,   -26.316576
        0.96,   -31.528926,         0.98,   -26.432406,           1.,   -21.339747,         1.02,   -16.247088
        1.04,   -16.443999,         1.06,   -16.644771,         1.08,    -9.374508,          1.1,    -2.104245
        1.12,     5.166018,         1.14,    12.436281,         1.16,    19.706544,         1.18,    26.976807
         1.2,     34.24707,         1.22,    17.467164,         1.24,     0.691119,         1.26,   -16.088787
        1.28,   -32.868693,          1.3,   -49.644738,         1.32,   -66.424644,         1.34,   -49.837788
        1.36,   -33.254793,         1.38,   -34.370622,          1.4,   -35.490312,         1.42,   -36.610002
        1.44,   -35.999964,         1.46,   -35.389926,         1.48,   -36.594558,          1.5,   -37.795329
        1.52,   -49.814622,         1.54,   -29.544372,         1.56,    -9.270261,         1.58,    10.999989
         1.6,    31.270239,         1.62,     51.54435,         1.64,      71.8146,         1.66,     92.08485
        1.68,    84.914973,          1.7,    77.741235,         1.72,    70.567497,         1.74,     63.39762
        1.76,    56.223882,         1.78,    62.328123,          1.8,    68.436225,         1.82,    51.023115
        1.84,    33.610005,         1.86,    16.200756,         1.88,    -1.212354,          1.9,   -18.625464
        1.92,   -36.038574,         1.94,   -53.447823,         1.96,   -70.860933,         1.98,   -88.274043
          2.,  -105.683292,         2.02,  -123.096402,         2.04,   -96.617664,         2.06,   -70.138926
        2.08,   -43.664049,          2.1,   -17.185311,         2.12,     9.293427,         2.14,    35.772165
        2.16,    62.250903,         2.18,    88.729641,          2.2,   115.208379,         2.22,    89.563617
        2.24,    63.914994,         2.26,    38.270232,         2.28,     12.62547,          2.3,   -13.019292
        2.32,   -38.664054,         2.34,   -64.308816,         2.36,   -89.957439,         2.38,  -115.602201
         2.4,    -1.625481,         2.42,   112.351239,         2.44,     86.40918,         2.46,    60.470982
        2.48,    34.528923,          2.5,     8.586864,         2.52,   -17.355195,         2.54,     7.081074
        2.56,    31.517343,         2.58,    55.949751,          2.6,     80.38602,         2.62,    73.254753
        2.64,    66.119625,         2.66,    53.123499,         2.68,    40.127373,          2.7,    27.131247
        2.72,    14.135121,         2.74,     1.138995,         2.76,   -11.857131,         2.78,    -2.166021
         2.8,     7.521228,         2.82,    17.212338,         2.84,    24.972948,         2.86,    32.733558
        2.88,    40.490307,          2.9,    22.760595,         2.92,     5.030883,         2.94,   -12.698829
        2.96,   -30.432402,         2.98,   -13.729716,           3.,     2.976831,         3.02,    19.679517
        3.04,     3.911193,         3.06,   -11.857131,         3.08,   -27.629316,          3.1,    -43.39764
        3.12,   -59.165964,         3.14,   -43.683354,         3.16,   -28.200744,         3.18,   -12.718134
         3.2,     2.760615,         3.22,    -24.51735,         3.24,   -51.795315,         3.26,    -79.07328
        3.28,   -48.193002,          3.3,   -17.316585,         3.32,    13.563693,         3.34,     44.44011
        3.36,    75.320388,         3.38,    47.494161,          3.4,    19.667934,         3.42,    -8.158293
        3.44,    -35.98452,         3.46,   -10.281843,         3.48,    15.424695,          3.5,    41.131233
        3.52,    66.837771,         3.54,    43.563663,         3.56,    20.289555,         3.58,    -2.980692
         3.6,     4.108104,         3.62,      11.1969,         3.64,    18.289557,         3.66,    25.378353
        3.68,     7.803081,          3.7,     -9.76833,         3.72,   -27.339741,         3.74,   -15.857127
        3.76,    -4.374513,         3.78,     1.111968,          3.8,     6.598449,         3.82,    12.088791
        3.84,    -8.795358,         3.86,   -29.675646,         3.88,   -50.559795,          3.9,   -71.443944
        3.92,   -55.393767,         3.94,    -39.34359,         3.96,   -23.297274,         3.98,    -7.247097
          4.,      8.80308,         4.02,    -3.845556,         4.04,   -16.494192,         4.06,    -8.289567
        4.08,    -0.081081,          4.1,     8.123544,         4.12,    -5.633199,         4.14,   -19.389942
        4.16,   -33.146685,         4.18,   -46.903428,          4.2,   -60.660171,         4.22,   -74.416914
        4.24,   -88.173657,         4.26,   -70.057845,         4.28,   -51.942033,          4.3,   -33.826221
        4.32,   -15.710409,         4.34,     2.405403,         4.36,    20.525076,         4.38,    38.640888
         4.4,      56.7567,         4.42,    37.660194,         4.44,    18.563688,         4.46,    -0.532818
        4.48,    19.849401,          4.5,     40.23162,         4.52,    60.613839,         4.54,    80.999919
        4.56,   101.382138,         4.58,    65.621556,          4.6,    29.860974,         4.62,    -5.895747
        4.64,   -41.656329,         4.66,   -77.416911,         4.68,   -26.200746,          4.7,    25.015419
        4.72,     6.451731,         4.74,   -12.111957,         4.76,   -30.675645,         4.78,   -49.239333
         4.8,   -67.803021,         4.82,   -86.366709,         4.84,  -104.930397,         4.86,   -61.200711
        4.88,   -17.471025,          4.9,    26.262522,         4.92,    69.992208,         4.94,    55.845504
        4.96,      41.6988,         4.98,    27.555957,           5.,    13.409253,         5.02,    37.320426
        5.04,     61.23546,         5.06,    85.146633,         5.08,    70.640856,          5.1,    56.131218
        5.12,     41.62158,         5.14,    27.115803,         5.16,    12.606165,         5.18,    25.671789
         5.2,    38.737413,         5.22,    51.803037,         5.24,    39.911157,         5.26,    28.019277
        5.28,    16.127397,          5.3,     4.235517,         5.32,    -7.656363,         5.34,    17.135118
        5.36,     41.93046,         5.38,    66.721941,          5.4,    40.216176,         5.42,    13.710411
        5.44,   -12.799215,         5.46,    -39.30498,         5.48,   -28.038582,          5.5,   -16.772184
        5.52,    -5.505786,         5.54,     5.760612,         5.56,    -7.818525,         5.58,   -21.401523
         5.6,    -34.98066,         5.62,   -48.563658,         5.64,   -62.142795,         5.66,   -75.725793
        5.68,   -57.081024,          5.7,   -38.436255,         5.72,   -19.795347,         5.74,    -1.150578
        5.76,    -7.536672,         5.78,   -13.918905,          5.8,   -20.304999,         5.82,   -16.146702
        5.84,   -11.992266,         5.86,   -11.208483,         5.88,   -10.420839,          5.9,     9.710415
        5.92,      6.83397,         5.94,     8.544393,         5.96,    10.254816,         5.98,     1.617759
          6.,    -7.023159,         6.02,   -15.664077,         6.04,   -24.301134,         6.06,    -9.332037
        6.08,      5.63706,          6.1,    20.606157,         6.12,     9.374508,         6.14,     -1.85328
        6.16,   -13.084929,         6.18,    -2.150577,          6.2,     8.779914,         6.22,     2.621619
        6.24,    -3.532815,         6.26,    -9.687249,         6.28,   -15.841683,          6.3,   -21.999978
        6.32,    -7.050186,         6.34,     7.899606,         6.36,     1.752894,         6.38,    -4.393818
         6.4,    -0.830115,         6.42,     2.733588,         6.44,     1.915056,         6.46,     1.100385
        6.48,     0.285714,          6.5,    -2.061774,         6.52,    -4.405401,         6.54,     1.393821
        6.56,     7.193043,         6.58,    12.992265,          6.6,    18.791487,         6.62,     11.73744
        6.64,     4.683393,         6.66,    -2.370654,         6.68,    -9.424701,          6.7,     5.308875
        6.72,     4.243239,         6.74,     3.177603,         6.76,     2.111967,         6.78,     3.135132
         6.8,     4.158297,         6.82,    -2.671812,         6.84,    -9.501921,         6.86,    -16.33203
        6.88,   -23.162139,          6.9,   -29.992248,         6.92,   -36.826218,         6.94,   -23.972949
        6.96,    -11.11968,         6.98,     1.729728,           7.,    14.582997,         7.02,     6.845553
        7.04,    -0.891891,         7.06,    -8.629335,         7.08,     6.915051,          7.1,    22.455576
        7.12,    14.432418,         7.14,      6.40926,         7.16,    -1.613898,         7.18,    -9.637056
         7.2,   -17.660214,         7.22,    -7.996131,         7.24,     1.667952,         7.26,    11.332035
        7.28,     5.891886,          7.3,     6.972966,         7.32,     8.054046,         7.34,     3.061773
        7.36,    -1.934361,         7.38,    -6.930495,          7.4,   -11.926629,         7.42,    -7.108101
        7.44,    -2.289573,         7.46,     2.528955,         7.48,    -9.725859,          7.5,   -21.980673
        7.52,   -15.617745,         7.54,    -9.258678,         7.56,     -2.89575,         7.58,     3.463317
         7.6,     1.482624,         7.62,    -0.498069,         7.64,    -2.478762,         7.66,    -4.463316
        7.68,   -10.111959,          7.7,   -15.760602,         7.72,   -21.409245,         7.74,   -16.857126
        7.76,   -12.308868,         7.78,   -26.888004,          7.8,   -21.752874,         7.82,   -16.613883
        7.84,   -11.474892,         7.86,    -6.339762,         7.88,    -1.200771,          7.9,      3.93822
        7.92,      9.07335,         7.94,    14.212341,         7.96,    19.347471,         7.98,     9.405396
          8.,    -0.536679,         8.02,   -10.478754,         8.04,    -1.193049,         8.06,     8.092656
        8.08,    17.378361,          8.1,    26.664066,         8.12,    22.289553,         8.14,     17.91504
        8.16,    13.540527,         8.18,    12.961377,          8.2,    12.382227,         8.22,    11.803077
        8.24,     12.54825,         8.26,    13.297284,         8.28,    14.042457,          8.3,     5.204628
        8.32,    -3.637062,         8.34,   -12.474891,         8.36,   -11.571417,         8.38,   -11.949795
         8.4,   -12.324312,         8.42,    -9.992268,         8.44,    -7.660224,         8.46,    -5.324319
        8.48,    -2.992275,          8.5,    -5.594589,         8.52,    -8.196903,         8.54,     5.880303
        8.56,     19.96137,         8.58,    34.038576,          8.6,    48.119643,         8.62,    62.196849
        8.64,    50.142807,         8.66,    38.084904,         8.68,    26.027001,          8.7,    13.969098
        8.72,     1.911195,         8.74,      1.62162,         8.76,     1.332045,         8.78,     1.038609
         8.8,   -22.864842,         8.82,   -46.764432,         8.84,   -70.667883,         8.86,   -46.498023
        8.88,   -22.324302,          8.9,     1.849419,         8.92,     26.02314,         8.94,    50.196861
        8.96,    32.328153,         8.98,    14.459445,           9.,    26.945919,         9.02,    39.432393
        9.04,   -13.579137,         9.06,   -66.590667,         9.08,   -53.138943,          9.1,   -39.683358
        9.12,   -26.231634,         9.14,    -12.77991,         9.16,   -14.081067,         9.18,   -15.382224
         9.2,    -1.996137,         9.22,     11.38995,         9.24,    24.776037,         9.26,    38.158263
        9.28,     51.54435,          9.3,    22.872564,         9.32,    -5.803083,         9.34,   -34.474869
        9.36,   -63.146655,         9.38,   -23.536656,          9.4,    16.077204,         9.42,     5.988411
        9.44,    -4.096521,         9.46,   -14.185314,         9.48,   -24.274107,          9.5,   -34.359039
        9.52,    -20.96523,         9.54,    -7.571421,         9.56,     5.822388,         9.58,    19.216197
         9.6,    32.610006,         9.62,    19.393803,         9.64,       6.1776,         9.66,    -7.038603
        9.68,   -20.254806,          9.7,   -33.471009,         9.72,   -26.135109,         9.74,    -18.80307
        9.76,    -11.46717,         9.78,    -4.135131,          9.8,     3.200769,         9.82,    -1.212354
        9.84,    11.451726,         9.86,    24.115806,         9.88,    -0.903474,          9.9,   -25.922754
        9.92,   -15.640911,         9.94,    -5.359068,         9.96,     4.918914,         9.98,     3.108105
         10.,    11.675664,        10.02,    20.243223,        10.04,     9.077211,        10.06,    -2.088801
       10.08,   -13.250952,         10.1,   -24.416964,        10.12,   -35.579115,        10.14,   -46.745127
       10.16,    -32.62545,        10.18,   -18.509634,         10.2,    -4.389957,        10.22,      9.72972
       10.24,    23.849397,        10.26,    15.552108,        10.28,      7.25868,         10.3,    17.204616
       10.32,    27.150552,        10.34,    37.096488,        10.36,    47.042424,        10.38,     24.51735
        10.4,     1.996137,        10.42,   -20.528937,        10.44,   -12.061764,        10.46,     -3.59073
       10.48,     4.876443,         10.5,    13.347477,        10.52,    12.675663,        10.54,    12.003849
       10.56,    11.332035,        10.58,    17.416971,         10.6,    23.501907,        10.62,    29.586843
       10.64,    35.671779,        10.66,    22.169862,        10.68,     8.667945,         10.7,    -4.833972
       10.72,      2.62548,        10.74,    10.081071,        10.76,    17.540523,        10.78,     6.065631
        10.8,    -5.413122,        10.82,   -16.888014,        10.84,   -28.366767,        10.86,    -15.40539
       10.88,    -2.444013,         10.9,    10.517364,        10.92,     23.47488,        10.94,    14.166009
       10.96,     4.857138,        10.98,    -4.451733,          11.,   -13.760604,        11.02,    -2.613897
       11.04,      8.53281,        11.06,    19.683378,        11.08,    30.830085,         11.1,    26.698815
       11.12,    22.567545,        11.14,    18.436275,        11.16,    14.308866,        11.18,    10.177596
        11.2,    22.478742,        11.22,    34.783749,        11.24,    47.088756,        11.26,    38.876409
       11.28,    30.667923,         11.3,    22.455576,        11.32,    14.243229,        11.34,     6.034743
       11.36,    -2.177604,        11.38,    -10.38609,         11.4,   -18.598437,        11.42,   -26.810784
       11.44,    -35.01927,        11.46,   -43.231617,        11.48,   -44.482581,         11.5,   -45.737406
       11.52,    -46.98837,        11.54,   -48.239334,        11.56,     -63.7065,        11.58,   -79.169805
        11.6,   -60.667893,        11.62,   -42.165981,        11.64,   -23.664069,        11.66,    -5.162157
       11.68,    13.339755,         11.7,    31.841667,        11.72,    29.250936,        11.74,    26.664066
       11.76,    24.077196,        11.78,    33.725835,         11.8,    43.378335,        11.82,    53.026974
       11.84,    47.007675,        11.86,    40.988376,        11.88,    34.969077,         11.9,    28.949778
       11.92,    30.930471,        11.94,    32.911164,        11.96,    34.891857,        11.98,    23.969088
         12.,    13.042458,        12.02,     2.119689,        12.04,    -8.806941,        12.06,   -21.019284
       12.08,    -15.55983,         12.1,   -10.096515,        12.12,    -4.637061,        12.14,    -7.830108
       12.16,   -11.023155,        12.18,   -24.104223,         12.2,   -13.606164,        12.22,    -3.108105
       12.24,   -19.104228,        12.26,   -14.065623,        12.28,    -9.023157,         12.3,   -13.003848
       12.32,    -7.254819,        12.34,    -1.501929,        12.36,       4.2471,        12.38,     9.996129
        12.4,     5.583006,        12.42,     1.169883,        12.44,     -3.24324,        12.46,     1.787643
       12.48,     6.818526,         12.5,    11.849409,        12.52,    16.880292,        12.54,     8.359065
       12.56,    -0.162162,        12.58,    -8.683389,         12.6,   -17.204616,        12.62,   -14.046318
       12.64,   -10.884159,        12.66,    -7.725861,        12.68,    -4.563702,         12.7,    -9.440145
       12.72,   -14.312727,        12.74,   -19.185309,        12.76,   -22.710402,        12.78,   -26.235495
        12.8,   -29.756727,        12.82,    -33.28182,        12.84,   -36.806913,        12.86,   -24.231636
       12.88,   -11.652498,         12.9,     0.922779,        12.92,    13.498056,        12.94,    16.984539
       12.96,    20.467161,        12.98,    12.262536,          13.,     4.057911,        13.02,    -4.142853
       13.04,   -12.347478,        13.06,   -20.552103,        13.08,     0.718146,         13.1,    21.992256
       13.12,     7.664085,        13.14,    -6.664086,        13.16,   -20.996118,        13.18,    -4.648644
        13.2,    11.702691,        13.22,    28.050165,        13.24,    44.397639,        13.26,    27.942057
       13.28,    11.486475,         13.3,    -4.972968,        13.32,     4.679532,        13.34,    14.328171
       13.36,    13.579137,        13.38,    12.830103,         13.4,     7.154433,        13.42,     1.478763
       13.44,     1.320462,        13.46,    -8.420841,        13.48,   -18.162144,         13.5,   -27.903447
       13.52,    -37.64475,        13.54,   -47.386053,        13.56,   -32.111937,        13.58,   -16.841682
        13.6,    -1.571427,        13.62,    13.702689,        13.64,    28.972944,        13.66,     44.24706
       13.68,    29.996109,         13.7,    15.745158,        13.72,     1.494207,        13.74,     1.096524
       13.76,     0.702702,        13.78,   -21.285693,         13.8,    18.270252,        13.82,    20.166003
       13.84,    22.065615,        13.86,    23.961366,        13.88,    25.860978,         13.9,    27.756729
       13.92,    10.444005,        13.94,    -6.868719,        13.96,   -24.181443,        13.98,   -41.494167
         14.,   -58.810752,        14.02,   -48.613851,        14.04,    -38.41695,        14.06,   -28.220049
       14.08,   -18.023148,         14.1,    -7.826247,        14.12,     2.370654,        14.14,    12.567555
       14.16,     3.316599,        14.18,    -5.934357,         14.2,   -15.181452,        14.22,   -24.432408
       14.24,   -12.826242,        14.26,    -1.216215,        14.28,    10.389951,         14.3,     4.617756
       14.32,      -1.1583,        14.34,     1.293435,        14.36,      3.74517,        14.38,     6.196905
        14.4,     8.644779,        14.42,    16.274115,        14.44,    23.903451,        14.46,    31.532787
       14.48,    13.424697,         14.5,    -4.679532,        14.52,    -5.054049,        14.54,    -5.432427
       14.56,   -20.362914,        14.58,    -9.822384,         14.6,     0.718146,        14.62,    11.258676
       14.64,    21.799206,        14.66,    32.339736,        14.68,     6.772194,         14.7,   -18.799209
       14.72,    -8.007714,        14.74,     2.787642,        14.76,    13.579137,        14.78,    -2.038608
        14.8,   -17.652492,        14.82,   -33.270237,        14.84,    -26.87256,        14.86,   -20.474883
       14.88,   -14.077206,         14.9,    -7.679529,        14.92,    -1.281852,        14.94,     5.115825
       14.96,    11.513502,        14.98,     4.250961,          15.,    -3.015441,        15.02,   -10.277982
       15.04,    -2.173743,        15.06,     5.930496,        15.08,    14.034735,         15.1,    22.138974
       15.12,    12.196899,        15.14,     2.254824,        15.16,    -7.691112,        15.18,    -0.776061
        15.2,     6.135129,        15.22,    -3.953664,        15.24,   -14.038596,        15.26,   -24.127389
       15.28,    -18.45558,         15.3,   -12.783771,        15.32,   -19.077201,        15.34,    -25.36677
       15.36,     -31.6602,        15.38,    -19.22778,         15.4,     -6.79536,        15.42,      5.63706
       15.44,     18.06948,        15.46,      30.5019,        15.48,     18.33975,         15.5,       6.1776
       15.52,     -5.98455,        15.54,    -0.393822,        15.56,     5.200767,        15.58,    10.791495
        15.6,    16.386084,        15.62,    21.976812,        15.64,    14.598441,        15.66,      7.22007
       15.68,    -0.158301,         15.7,    -7.536672,        15.72,    -1.648647,        15.74,     4.239378
       15.76,    10.127403,        15.78,    16.015428,         15.8,     7.030881,        15.82,    -1.953666
       15.84,    -3.374514,        15.86,   -14.386086,        15.88,   -25.401519,         15.9,     -10.0386
       15.92,      5.32818,        15.94,    20.691099,        15.96,    36.054018,        15.98,    22.714263
         16.,     9.378369,        16.02,    -3.961386,        16.04,    -17.29728,        16.06,    -4.181463
       16.08,    -7.216209,         16.1,   -10.250955,        16.12,   -13.285701,        16.14,    -9.664083
       16.16,    -6.038604,        16.18,    -2.416986,         16.2,    -3.895749,        16.22,    -5.374512
       16.24,      5.75289,        16.26,    16.880292,        16.28,    13.370643,         16.3,     8.100378
       16.32,     2.830113,        16.34,    -2.440152,        16.36,    -7.710417,        16.38,     2.961387
        16.4,    13.637052,        16.42,    13.162149,        16.44,    12.691107,        16.46,    12.216204
       16.48,     9.277983,         16.5,     6.339762,        16.52,     3.791502,        16.54,     1.243242
       16.56,    -1.308879,        16.58,     8.501922,         16.6,    -7.494201,        16.62,   -23.494185
       16.64,   -39.490308,        16.66,   -30.297267,        16.68,   -21.104226,         16.7,   -11.907324
       16.72,    -2.714283,        16.74,     6.478758,        16.76,     7.513506,        16.78,     8.548254
        16.8,     9.586863,        16.82,     6.984549,        16.84,    -0.779922,        16.86,    -8.544393
       16.88,    -1.073358,         16.9,     6.393816,        16.92,     13.86099,        16.94,    21.332025
       16.96,    28.799199,        16.98,    23.949783,          17.,    19.104228,        17.02,    14.254812
       17.04,    -0.559845,        17.06,    17.756739,        17.08,    15.749019,         17.1,    13.737438
       17.12,    11.725857,        17.14,    13.999986,        17.16,    16.274115,        17.18,    18.544383
        17.2,    20.818512,        17.22,    19.100367,        17.24,    17.382222,        17.26,    15.660216
       17.28,    13.942071,         17.3,    12.223926,        17.32,     2.370654,        17.34,    -7.478757
       17.36,   -17.332029,        17.38,    -27.18144,         17.4,   -37.034712,        17.42,   -29.903445
       17.44,   -22.776039,        17.46,   -15.644772,        17.48,    -8.517366,         17.5,    -1.386099
       17.52,     5.741307,        17.54,     3.880305,        17.56,     2.019303,        17.58,     0.158301
        17.6,    -1.702701,        17.62,    -3.563703,        17.64,    -4.590729,        17.66,    -5.880303
       17.68,    -7.166016,         17.7,     -8.45559,        17.72,    -3.795363,        17.74,     0.864864
       17.76,     5.525091,        17.78,     1.293435,         17.8,     -2.93436,        17.82,    -7.166016
       17.84,    -2.845557,        17.86,     1.478763,        17.88,     5.799222,         17.9,    10.123542
       17.92,     3.922776,        17.94,     -2.27799,        17.96,    -8.478756,        17.98,    -0.467181
         18.,     7.540533,        18.02,    15.548247,        18.04,    10.911186,        18.06,     6.274125
       18.08,     1.637064,         18.1,     0.756756,        18.12,    -0.119691,        18.14,    -0.996138
       18.16,    -1.876446,        18.18,    -2.752893,         18.2,    -3.633201,        18.22,    -4.509648
       18.24,    -5.389956,        18.26,     -6.75675,        18.28,    -8.123544,         18.3,    -9.490338
       18.32,   -10.860993,        18.34,   -12.227787,        18.36,   -13.594581,        18.38,   -16.235505
        18.4,   -18.876429,        18.42,   -13.741299,        18.44,    -8.606169,        18.46,    -3.471039
       18.48,     1.664091,         18.5,     6.803082,        18.52,     2.756754,        18.54,    -1.289574
       18.56,    -5.339763,        18.58,     5.073354,         18.6,    15.486471,        18.62,    25.899588
       18.64,     18.61002,        18.66,    11.320452,        18.68,     4.027023,         18.7,    -3.262545
       18.72,   -10.552113,        18.74,   -17.841681,        18.76,   -12.181455,        18.78,    -6.517368
        18.8,    -0.857142,        18.82,     4.803084,        18.84,    10.359063,        18.86,    15.911181
       18.88,    21.463299,         18.9,    12.559833,        18.92,     3.652506,        18.94,     -5.25096
       18.96,    -5.528952,        18.98,    -5.806944,          19.,    -6.084936,        19.02,   -16.250949
       19.04,   -10.366785,        19.06,    -4.482621,        19.08,     1.401543,         19.1,     7.285707
       19.12,    13.169871,        19.14,    12.027015,        19.16,    10.884159,        19.18,    11.262537
        19.2,    11.640915,        19.22,    12.019293,        19.24,     1.498068,        19.26,    -9.023157
       19.28,   -19.544382,         19.3,    -14.74902,        19.32,    -9.957519,        19.34,    -5.162157
       19.36,    -0.366795,        19.38,     4.424706,         19.4,     9.220068,        19.42,    14.011569
       19.44,     4.042467,        19.46,    -5.926635,        19.48,   -15.895737,         19.5,   -25.864839
       19.52,   -20.104227,        19.54,   -14.343615,        19.56,    -8.579142,        19.58,     -2.81853
        19.6,     2.942082,        19.62,     8.702694,        19.64,    14.467167,        19.66,    15.447861
       19.68,    16.432416,         19.7,    17.401527,        19.72,    18.374499,        19.74,     19.34361
       19.76,    17.548245,        19.78,     15.75288,         19.8,    11.104236,        19.82,     6.451731
       19.84,     1.803087,        19.86,    -2.849418,        19.88,    -0.447876,         19.9,     1.953666
       19.92,     4.355208,        19.94,      6.75675,        19.96,    -0.814671,        19.98,    -8.389953
         20.,   -15.965235,        20.02,   -23.536656,        20.04,   -31.111938,        20.06,   -27.007695
       20.08,   -22.899591,         20.1,   -18.795348,        20.12,   -14.691105,        20.14,    -9.872577
       20.16,     -5.05791,        20.18,    -0.243243,         20.2,     4.575285,        20.22,     9.389952
       20.24,     14.20848,        20.26,    19.023147,        20.28,    11.482614,         20.3,     3.942081
       20.32,    -3.598452,        20.34,   -11.135124,        20.36,   -18.675657,        20.38,    -26.21619
        20.4,   -18.772182,        20.42,   -11.328174,        20.44,    -3.884166,        20.46,     3.559842
       20.48,    11.007711,         20.5,    18.451719,        20.52,     9.482616,        20.54,     0.513513
       20.56,     -8.45559,        20.58,   -17.424693,         20.6,   -26.393796,        20.62,   -19.220058
       20.64,    -12.04632,        20.66,    -4.872582,        20.68,     2.301156,         20.7,     9.471033
       20.72,    16.644771,        20.74,    23.818509,        20.76,    30.992247,        20.78,    38.165985
        20.8,    24.911172,        20.82,    11.656359,        20.84,    -1.598454,        20.86,   -14.857128
       20.88,   -28.111941,         20.9,   -23.162139,        20.92,   -18.212337,        20.94,    13.262535
       20.96,   -12.474891,        20.98,   -11.691108,          21.,   -10.903464,        21.02,    -1.528956
       21.04,     7.845552,        21.06,     1.208493,        21.08,    -5.428566,         21.1,   -12.061764
       21.12,   -18.698823,        21.14,   -25.335882,        21.16,   -19.814652,        21.18,   -14.293422
        21.2,    -8.772192,        21.22,    -3.254823,        21.24,     2.266407,        21.26,     7.787637
       21.28,    10.416978,         21.3,    13.046319,        21.32,    15.679521,        21.34,    18.308862
       21.36,    20.938203,        21.38,    13.648635,         21.4,     6.359067,        21.42,     6.262542
       21.44,     6.169878,        21.46,     6.077214,        21.48,     2.884167,         21.5,     -0.30888
       21.52,    -3.501927,        21.54,     0.277992,        21.56,     4.057911,        21.58,      7.83783
        21.6,    11.617749,        21.62,    15.401529,        21.64,    13.428558,        21.66,    11.455587
       21.68,     9.486477,         21.7,    11.872575,        21.72,    14.262534,        21.74,    16.652493
       21.76,    19.038591,        21.78,     21.42855,         21.8,    23.814648,        21.82,    -2.030886
       21.84,    -27.87642,        21.86,   -24.463296,        21.88,   -21.046311,         21.9,   -17.629326
       21.92,   -14.212341,        21.94,   -14.200758,        21.96,   -14.189175,        21.98,   -14.177592
         22.,    -6.814665,        22.02,     0.552123,        22.04,     7.918911,        22.06,    15.281838
       22.08,    22.648626,         22.1,    13.729716,        22.12,     4.806945,        22.14,    -4.115826
       22.16,   -13.034736,        22.18,   -21.957507,         22.2,   -17.382222,        22.22,   -12.806937
       22.24,    -8.227791,        22.26,    -3.652506,        22.28,     0.922779,         22.3,    -0.803088
       22.32,    -2.525094,        22.34,    -4.250961,        22.36,    -5.976828,        22.38,      -4.6332
        22.4,    -3.285711,        22.42,    -1.942083,        22.44,    -0.594594,        22.46,     0.752895
       22.48,     0.196911,         22.5,    -0.355212,        22.52,     4.382235,        22.54,     9.123543
       22.56,     13.86099,        22.58,    18.602298,         22.6,    23.339745,        22.62,    28.081053
       22.64,    10.992267,        22.66,    -6.096519,        22.68,   -23.181444,         22.7,   -19.571409
       22.72,   -15.961374,        22.74,   -12.351339,        22.76,   -12.104235,        22.78,   -11.857131
        22.8,   -11.610027,        22.82,    -7.193043,        22.84,    -2.776059,        22.86,     1.640925
       22.88,      6.06177,         22.9,    10.478754,        22.92,    14.895738,        22.94,    11.486475
       22.96,     8.077212,        22.98,     9.011574,          23.,     9.945936,        23.02,    10.884159
       23.04,    11.818521,        23.06,    12.756744,        23.08,     5.293431,         23.1,    -2.166021
       23.12,    -9.629334,        23.14,    -8.525088,        23.16,    -7.424703,        23.18,    -6.324318
        23.2,    -5.223933,        23.22,    -4.868721,        23.24,     -4.51737,        23.26,    -0.652509
       23.28,     3.216213,         23.3,     7.081074,        23.32,    10.945935,        23.34,    14.810796
       23.36,    18.679518,        23.38,    14.474889,         23.4,     10.27026,        23.42,     6.065631
       23.44,     1.861002,        23.46,    -2.343627,        23.48,    -6.548256,         23.5,     -3.01158
       23.52,     0.525096,        23.54,     4.061772,        23.56,     7.598448,        23.58,    11.135124
        23.6,    -1.945944,        23.62,   -15.030873,        23.64,    -9.042462,        23.66,    -3.054051
       23.68,     2.930499,         23.7,      8.91891,        23.72,     2.729727,        23.74,    -3.455595
       23.76,    -9.644778,        23.78,     -15.8301,         23.8,   -22.019283,        23.82,    -11.27412
       23.84,    -0.528957,        23.86,    10.212345,        23.88,    20.957508,         23.9,    13.849407
       23.92,     6.741306,        23.94,    -0.370656,        23.96,    -7.478757,        23.98,   -14.586858
         24.,    -8.806941,        24.02,    -3.027024,        24.04,     2.752893,        24.06,      8.53281
       24.08,    14.312727,         24.1,    20.092644,        24.12,    25.872561,        24.14,    31.652478
       24.16,    11.911185,        24.18,    -7.826247,         24.2,    -27.56754,        24.22,   -47.308833
       24.24,   -33.374484,        24.26,   -19.440135,        24.28,    -5.505786,         24.3,     8.428563
       24.32,    22.362912,        24.34,      36.2934,        24.36,    50.227749,        24.38,    13.942071
        24.4,   -22.343607,        24.42,   -18.540522,        24.44,   -14.737437,        24.46,   -10.934352
       24.48,    -7.127406,         24.5,    -3.324321,        24.52,   -14.100372,        24.54,   -24.880284
       24.56,   -23.818509,        24.58,   -22.756734,         24.6,   -21.691098,        24.62,   -23.447853
       24.64,   -25.204608,        24.66,   -17.868708,        24.68,   -10.532808,         24.7,    -3.200769
       24.72,     4.135131,        24.74,     11.46717,        24.76,    12.115818,        24.78,    12.764466
        24.8,    13.413114,        24.82,    14.061762,        24.84,    17.660214,        24.86,    21.258666
       24.88,    24.860979,         24.9,    28.459431,        24.92,    32.057883,        24.94,    13.918905
       24.96,    -4.216212,        24.98,    -22.35519,          25.,   -18.131256,        25.02,   -13.907322
       25.04,    -9.683388,        25.06,    -5.459454,        25.08,   -13.749021,         25.1,   -22.038588
       25.12,   -30.328155,        25.14,   -24.339744,        25.16,   -18.351333,        25.18,   -12.366783
        25.2,    -6.378372,        25.22,    -0.393822,        25.24,     3.559842,        25.26,     7.513506
       25.28,     11.46717,         25.3,    15.416973,        25.32,    19.370637,        25.34,    23.324301
       25.36,    27.277965,        25.38,    31.231629,         25.4,    -0.741312,        25.42,   -32.714253
       25.44,   -27.150552,        25.46,    -21.58299,        25.48,   -16.015428,         25.5,   -20.447856
       25.52,   -24.876423,        25.54,    -29.30499,        25.56,   -33.737418,        25.58,   -38.165985
        25.6,   -26.247078,        25.62,    -14.32431,        25.64,    -2.405403,        25.66,     9.517365
       25.68,    21.440133,         25.7,     33.35904,        25.72,    45.281808,        25.74,    57.200715
       25.76,    33.648615,        25.78,    10.096515,         25.8,   -13.455585,        25.82,   -37.003824
       25.84,     -27.4131,        25.86,   -17.822376,        25.88,    -8.231652,         25.9,     1.362933
       25.92,    10.953657,        25.94,    20.544381,        25.96,    -1.810809,        25.98,   -24.162138
         26.,   -46.517328,        26.02,    -38.45556,        26.04,   -30.393792,        26.06,   -22.332024
       26.08,   -14.270256,         26.1,    -6.208488,        26.12,      1.85328,        26.14,     9.915048
       26.16,    17.976816,        26.18,    26.038584,         26.2,    34.100352,        26.22,     42.16212
       26.24,    50.223888,        26.26,    42.451695,        26.28,    34.679502,         26.3,    26.907309
       26.32,    19.131255,        26.34,    15.467166,        26.36,    11.799216,        26.38,     8.135127
        26.4,     4.471038,        26.42,      3.01158,        26.44,     1.552122,        26.46,     0.092664
       26.48,    -1.366794,         26.5,    -2.826252,        26.52,     -4.28571,        26.54,     -3.01158
       26.56,     -1.73745,        26.58,     -0.46332,         26.6,      0.81081,        26.62,      2.08494
       26.64,    -3.208491,        26.66,    -8.505783,        26.68,   -13.803075,         26.7,   -19.100367
       26.72,   -24.397659,        26.74,   -19.482606,        26.76,   -14.567553,        26.78,      -9.6525
        26.8,    -4.737447,        26.82,     0.177606,        26.84,     1.861002,        26.86,     3.548259
       26.88,     5.231655,         26.9,     6.915051,        26.92,     8.602308,        26.94,     3.409263
       26.96,    -1.783782,        26.98,    -6.976827,          27.,   -12.169872,        27.02,    -8.787636
       27.04,    -5.409261,        27.06,    -2.030886,        27.08,      1.35135,         27.1,     4.729725
       27.12,     8.111961,        27.14,     5.548257,        27.16,     2.984553,        27.18,      0.42471
        27.2,     3.177603,        27.22,     5.934357,        27.24,     8.691111,        27.26,     6.613893
       27.28,     4.536675,         27.3,     2.459457,        27.32,     5.312736,        27.34,     8.162154
       27.36,    11.011572,        27.38,    13.864851,         27.4,    16.714269,        27.42,    13.351338
       27.44,     9.988407,        27.46,     6.621615,        27.48,     3.258684,         27.5,    -0.104247
       27.52,    -3.467178,        27.54,    -0.486486,        27.56,     2.490345,        27.58,     5.471037
        27.6,     7.872579,        27.62,    10.274121,        27.64,    12.675663,        27.66,    15.077205
       27.68,    17.478747,         27.7,    14.050179,        27.72,     10.61775,        27.74,     7.189182
       27.76,     3.760614,        27.78,     0.332046,         27.8,    -5.146713,        27.82,   -10.625472
       27.84,   -16.104231,        27.86,   -10.857132,        27.88,    -5.610033,         27.9,    -0.362934
       27.92,     4.880304,        27.94,    10.127403,        27.96,      6.52509,        27.98,     2.918916
         28.,    -0.683397,        28.02,    -4.289571,        28.04,    -7.891884,        28.06,   -11.494197
       28.08,   -15.100371,         28.1,    -9.428562,        28.12,    -3.756753,        28.14,     1.915056
       28.16,     7.586865,        28.18,    13.258674,         28.2,     7.930494,        28.22,     2.602314
       28.24,    -2.725866,        28.26,    -8.054046,        28.28,   -13.382226,         28.3,   -10.281843
       28.32,     -7.18146,        28.34,    -4.081077,        28.36,    -0.980694,        28.38,    -0.243243
        28.4,     0.494208,        28.42,     1.231659,        28.44,      1.96911,        28.46,     3.857139
       28.48,     5.745168,         28.5,     3.054051,        28.52,     0.359073,        28.54,    -2.335905
       28.56,     1.320462,        28.58,     4.972968,         28.6,     8.629335,        28.62,    12.281841
       28.64,    15.938208,        28.66,    10.451727,        28.68,     4.969107,         28.7,    -0.517374
       28.72,    -5.999994,        28.74,   -11.486475,        28.76,   -16.969095,        28.78,   -13.945932
        28.8,   -10.918908,        28.82,    -7.891884,        28.84,     -4.86486,        28.86,    -1.837836
       28.88,     1.185327,         28.9,     4.212351,        28.92,     3.799224,        28.94,     3.382236
       28.96,     2.965248,        28.98,     2.552121,          29.,     4.764474,        29.02,     6.976827
       29.04,      9.18918,        29.06,    11.401533,        29.08,    13.613886,         29.1,    10.749024
       29.12,     7.884162,        29.14,       5.0193,        29.16,   -13.185315,        29.18,    -2.424708
        29.2,    -2.397681,        29.22,    -2.374515,        29.24,    -2.351349,        29.26,    -2.324322
       29.28,    -2.301156,         29.3,     -2.27799,        29.32,    -2.250963,        29.34,    -2.227797
       29.36,    -2.204631,        29.38,    -2.177604,         29.4,    -2.154438,        29.42,    -2.131272
       29.44,    -2.104245,        29.46,    -2.081079,        29.48,    -2.054052,         29.5,    -2.030886
       29.52,     -2.00772,        29.54,    -1.980693,        29.56,    -1.957527,        29.58,    -1.934361
        29.6,    -1.907334,        29.62,    -1.884168,        29.64,    -1.861002,        29.66,    -1.833975
       29.68,    -1.810809,         29.7,    -1.787643,        29.72,    -1.760616,        29.74,     -1.73745
       29.76,    -1.714284,        29.78,    -1.687257,         29.8,    -1.664091,        29.82,    -1.640925
       29.84,    -1.613898,        29.86,    -1.590732,        29.88,    -1.567566,         29.9,    -1.540539
       29.92,    -1.517373,        29.94,    -1.494207,        29.96,     -1.46718,        29.98,    -1.444014
         30.,    -1.420848,        30.02,    -1.393821,        30.04,    -1.370655,        30.06,    -1.347489
       30.08,    -1.320462,         30.1,    -1.297296,        30.12,     -1.27413,        30.14,    -1.247103
       30.16,    -1.223937,        30.18,    -1.200771,         30.2,    -1.173744,        30.22,    -1.150578
       30.24,    -1.127412,        30.26,    -1.100385,        30.28,    -1.077219,         30.3,    -1.054053
       30.32,    -1.027026,        30.34,     -1.00386,        30.36,    -0.980694,        30.38,    -0.953667
        30.4,    -0.930501,        30.42,    -0.907335,        30.44,    -0.880308,        30.46,    -0.857142
       30.48,    -0.833976,         30.5,    -0.806949,        30.52,    -0.783783,        30.54,    -0.760617
       30.56,     -0.73359,        30.58,    -0.710424,         30.6,    -0.687258,        30.62,    -0.660231
       30.64,    -0.637065,        30.66,    -0.610038,        30.68,    -0.586872,         30.7,    -0.563706
       30.72,    -0.536679,        30.74,    -0.513513,        30.76,    -0.490347,        30.78,     -0.46332
        30.8,    -0.440154,        30.82,    -0.416988,        30.84,    -0.389961,        30.86,    -0.366795
       30.88,    -0.343629,         30.9,    -0.316602,        30.92,    -0.293436,        30.94,     -0.27027
       30.96,    -0.243243,        30.98,    -0.220077,          31.,    -0.196911,        31.02,    -0.169884
       31.04,    -0.146718,        31.06,    -0.123552,        31.08,    -0.096525,         31.1,    -0.073359
       31.12,    -0.050193,        31.14,    -0.023166,        31.16,           0.,        31.18,           0.